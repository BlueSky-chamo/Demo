# Keil uVision project Frame.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Frame
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Common;..\Lib;..\StartUp;..\User
  group StartUp
    ../StartUp/: STARTUP.A51
  group User
    ../User/: main.c
  group Lib
    ../Lib/: Beep.c Key.c Led.c
  group Common
    ../Common/: common.c
